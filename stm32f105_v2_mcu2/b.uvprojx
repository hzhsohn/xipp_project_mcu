# Keil uVision project b.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F105VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: xipp
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\user;.\libs\inc;.\dev;.\app
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c mini-data.c global.h system_init.h
  group libs
    ./libs/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c misc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_flash.c
    ./libs/inc/: conf.h
  group dev
    ./dev/: STM32_Delay.c ds18b20.c ds18b20_1.c Motor_Diver.c stm32f10x_wwdg.c watchdog.c stm32f10x_iwdg.c Stm32F1_Timer2.c Stm32F1_Timer3.c key.c flash_rw.c OutputDrive.c STM32F1_UART1.c STM32F1_UART2.c STM32F1_UART3.c STM32F1_ADC1.c STM32F1_ADC2.c STM32F1_ADC3.c STM32F1_ADC4.c InputDrive.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
