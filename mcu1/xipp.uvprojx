# Keil uVision project xipp.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F105VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: xipp
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\user;.\libs\inc;.\dev;.\app
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c system_init.c mini-data.c flash_rw.c
  group libs
    ./libs/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c misc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_flash.c
    ./libs/inc/: conf.h
  group dev
    ./dev/: BeeSpeaker_Diver.c TouchKey_Diver.c Stm32F1_Timer3.c STM32_Delay.c Relay_Diver.c Sensor.c STM32F1_UART1_Diver.c STM32F1_UART2_Diver.c STM32F1_UART3_Diver.c ds18b20.c STM32F1_ADC1_Diver.c Motor_Diver.c STM32F1_ADC2_Diver.c ds18b20_1.c stm32f10x_wwdg.c watchdog.c stm32f10x_iwdg.c Stm32F1_Timer2.c
  group app
    ./app/: AutoFunction.c SenceAct.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
